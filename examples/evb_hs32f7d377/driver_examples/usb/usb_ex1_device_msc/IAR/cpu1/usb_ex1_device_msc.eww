<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\usb_ex1_device_msc.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>