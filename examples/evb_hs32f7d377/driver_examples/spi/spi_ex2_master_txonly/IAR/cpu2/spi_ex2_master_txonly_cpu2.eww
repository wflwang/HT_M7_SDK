<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\spi_ex2_master_txonly_cpu2.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>