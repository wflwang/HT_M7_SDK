<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\spi_ex1_master_norflash_cpu1.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>