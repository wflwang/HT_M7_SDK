# IAR project spi_ex1_master_norflash_cpu2.ewp, settings and files
configuration spi_ex1_master_norflash_cpu2_itcm_debug (ARM, debug)
  General.OGChipSelectEditMenu: HS32F7D377_CPU2 Watech HS32F7D377_CPU2
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: HTE_DEVICE_HS32F7D377_CPU2; DEBUG
  ICCARM.CCIncludePath2: ..\..; ..\..\..\..\..\..\..\boards\evb_hs32f7d377; ..\..\..\..\..\..\..\components\debug_console; ..\..\..\..\..\..\..\devices\HS32F7D377; ..\..\..\..\..\..\..\devices\HS32F7D377\drivers; ..\..\..\..\..\..\..\drivers\common; ..\..\..\..\..\..\..\drivers\dma; ..\..\..\..\..\..\..\drivers\gpio; ..\..\..\..\..\..\..\drivers\ipc; ..\..\..\..\..\..\..\drivers\spi; ..\..\..\..\..\..\..\drivers\uart; ..\..\..\..\..\..\..\middleware\SPI_NORFLASH; ..\..\..\..\..\..\..\CMSIS\Core\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: HTE_DEVICE_HS32F7D377_CPU2; DEBUG
  OBJCOPY.OOCOutputFile: spi_ex1_master_norflash_cpu2_itcm_debug.srec
  ILINK.IlinkOutputFile: spi_ex1_master_norflash_cpu2_itcm_debug.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\devices\HS32F7D377\IAR\HS32F7D377_cpu2_itcm.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration spi_ex1_master_norflash_cpu2_itcm_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HTE_DEVICE_HS32F7D377_CPU2; NDEBUG; RELEASE
  ICCARM.CCIncludePath2: ..\..; ..\..\..\..\..\..\..\boards\evb_hs32f7d377; ..\..\..\..\..\..\..\components\debug_console; ..\..\..\..\..\..\..\devices\HS32F7D377; ..\..\..\..\..\..\..\devices\HS32F7D377\drivers; ..\..\..\..\..\..\..\drivers\common; ..\..\..\..\..\..\..\drivers\dma; ..\..\..\..\..\..\..\drivers\gpio; ..\..\..\..\..\..\..\drivers\spi; ..\..\..\..\..\..\..\drivers\uart; ..\..\..\..\..\..\..\middleware\SPI_NORFLASH; ..\..\..\..\..\..\..\CMSIS\Core\Include
  AARM.ADefines: HTE_DEVICE_HS32F7D377_CPU2; NDEBUG; RELEASE
  OBJCOPY.OOCOutputFile: spi_ex1_master_norflash_cpu2_itcm_release.bin
  ILINK.IlinkOutputFile: spi_ex1_master_norflash_cpu2_itcm_release.out
configuration spi_ex1_master_norflash_cpu2_eflash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: spi_ex1_master_norflash_cpu2_eflash_debug.srec
  ILINK.IlinkOutputFile: spi_ex1_master_norflash_cpu2_eflash_debug.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\devices\HS32F7D377\IAR\HS32F7D377_cpu2_eflash.icf
configuration spi_ex1_master_norflash_cpu2_eflash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HTE_DEVICE_HS32F7D377_CPU2; NDEBUG; RELEASE
  ICCARM.CCIncludePath2: as above
  AARM.ADefines: HTE_DEVICE_HS32F7D377_CPU2; NDEBUG; RELEASE
  OBJCOPY.OOCOutputFile: spi_ex1_master_norflash_cpu2_eflash_release.bin
  ILINK.IlinkOutputFile: spi_ex1_master_norflash_cpu2_eflash_release.out
  ILINK.IlinkIcfFile: as above
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/m-profile/: armv7m_cachel1.h armv7m_mpu.h cmsis_armclang_m.h
    ../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm7.h
  group board
    ../../../../../../../boards/evb_hs32f7d377/: board.c board.h clock_config.c clock_config.h
  group component
    ../../../../../../../components/assert/: hte_assert.c
    ../../../../../../../components/debug_console/: hte_debug_console.c hte_debug_console.h
  group device
    ../../../../../../../devices/HS32F7D377/: HS32F7D377_cpu2.h HS32F7D377_cpu2_features.h hte_device.h system_HS32F7D377_cpu2.c system_HS32F7D377_cpu2.h
  group driver
    ../../../../../../../drivers/common/: hte_common.c hte_common.h
    ../../../../../../../drivers/dma/: hte_dma.c
    ../../../../../../../drivers/gpio/: hte_gpio.c hte_gpio.h
    ../../../../../../../drivers/spi/: hte_spi.c
    ../../../../../../../drivers/uart/: hte_uart.c hte_uart.h
  group middleware/SPI_NORFLASH
    ../../../../../../../middleware/SPI_NORFLASH/: mt25qxx.c spi_norflash.c
  group source
    ../../: spi_ex1_master_norflash.c
  group startup
    ../../../../../../../devices/HS32F7D377/IAR/: startup_HS32F7D377_cpu2.s
