<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\cpu1\sdfm_ex2_filter_sync_dmaread_cpu1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\cpu2\sdfm_ex2_filter_sync_dmaread_cpu2.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>1</name>
            <member>
                <project>sdfm_ex2_filter_sync_dmaread_cpu1</project>
                <configuration>sdfm_ex2_filter_sync_dmaread_cpu1_eflash_debug</configuration>
            </member>
            <member>
                <project>sdfm_ex2_filter_sync_dmaread_cpu1</project>
                <configuration>sdfm_ex2_filter_sync_dmaread_cpu1_eflash_release</configuration>
            </member>
            <member>
                <project>sdfm_ex2_filter_sync_dmaread_cpu1</project>
                <configuration>sdfm_ex2_filter_sync_dmaread_cpu1_itcm_debug</configuration>
            </member>
            <member>
                <project>sdfm_ex2_filter_sync_dmaread_cpu1</project>
                <configuration>sdfm_ex2_filter_sync_dmaread_cpu1_itcm_release</configuration>
            </member>
            <member>
                <project>sdfm_ex2_filter_sync_dmaread_cpu2</project>
                <configuration>sdfm_ex2_filter_sync_dmaread_cpu2_eflash_debug</configuration>
            </member>
            <member>
                <project>sdfm_ex2_filter_sync_dmaread_cpu2</project>
                <configuration>sdfm_ex2_filter_sync_dmaread_cpu2_eflash_release</configuration>
            </member>
            <member>
                <project>sdfm_ex2_filter_sync_dmaread_cpu2</project>
                <configuration>sdfm_ex2_filter_sync_dmaread_cpu2_itcm_debug</configuration>
            </member>
            <member>
                <project>sdfm_ex2_filter_sync_dmaread_cpu2</project>
                <configuration>sdfm_ex2_filter_sync_dmaread_cpu2_itcm_release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
