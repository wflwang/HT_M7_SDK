<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\sdfm_ex2_filter_sync_dmaread_cpu2.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>