<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\sdfm_ex4_type1_filter_fifo_cpuread_cpu1.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>