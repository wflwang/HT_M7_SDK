<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\..\IAR\cpu1\sdfm_ex1_filter_sync_cpuread_cpu1.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\IAR\cpu2\sdfm_ex1_filter_sync_cpuread_cpu2.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>