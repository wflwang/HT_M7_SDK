<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\sdfm_ex1_filter_sync_cpuread_cpu2.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>