<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\sdfm_ex3_pwm_sync_cpuread_cpu2.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>