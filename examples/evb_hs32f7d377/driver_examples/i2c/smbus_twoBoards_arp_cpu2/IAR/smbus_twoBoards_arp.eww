<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\..\IAR\cpu1\smbus_twoBoards_arp_cpu1.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\IAR\cpu2\smbus_twoBoards_arp_cpu2.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>