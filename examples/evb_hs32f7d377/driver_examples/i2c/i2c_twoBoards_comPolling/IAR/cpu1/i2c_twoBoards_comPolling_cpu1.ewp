# IAR project i2c_twoBoards_comPolling_cpu1.ewp, settings and files
configuration i2c_twoBoards_comPolling_cpu1_itcm_debug (ARM, debug)
  General.OGChipSelectEditMenu: HS32F7D377_CPU1 Watech HS32F7D377_CPU1
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: HTE_DEVICE_HS32F7D377_CPU1; BOARD_CONFIG_CPU2; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\CMSIS\Core\Include; ..\..\..\..\..\..\..\boards\evb_hs32f7d377; ..\..\..\..\..\..\..\components\debug_console; ..\..\..\..\..\..\..\devices\HS32F7D377; ..\..\..\..\..\..\..\devices\HS32F7D377\drivers; ..\..\..\..\..\..\..\drivers\common; ..\..\..\..\..\..\..\drivers\gpio; ..\..\..\..\..\..\..\drivers\i2c; ..\..\..\..\..\..\..\drivers\ipc; ..\..\..\..\..\..\..\drivers\uart; ..\..\..\..\..\..\..\drivers\xbar; ..\..\..\..\..\..\..\components
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: HTE_DEVICE_HS32F7D377_CPU1; BOARD_CONFIG_CPU2; DEBUG
  OBJCOPY.OOCOutputFile: i2c_twoBoards_comPolling_cpu1_itcm_debug.srec
  ILINK.IlinkOutputFile: i2c_twoBoards_comPolling_cpu1_itcm_debug.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\devices\HS32F7D377\IAR\HS32F7D377_cpu1_itcm.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration i2c_twoBoards_comPolling_cpu1_itcm_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HTE_DEVICE_HS32F7D377_CPU1; BOARD_CONFIG_CPU2; NDEBUG; RELEASE
  AARM.ADefines: HTE_DEVICE_HS32F7D377_CPU1; NDEBUG; RELEASE
  OBJCOPY.OOCOutputFile: i2c_twoBoards_comPolling_cpu1_itcm_release.bin
  ILINK.IlinkOutputFile: i2c_twoBoards_comPolling_cpu1_itcm_release.out
configuration i2c_twoBoards_comPolling_cpu1_eflash_debug (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: i2c_twoBoards_comPolling_cpu1_eflash_debug.srec
  ILINK.IlinkOutputFile: i2c_twoBoards_comPolling_cpu1_eflash_debug.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\devices\HS32F7D377\IAR\HS32F7D377_cpu1_eflash.icf
configuration i2c_twoBoards_comPolling_cpu1_eflash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  AARM.ADefines: HTE_DEVICE_HS32F7D377_CPU1; NDEBUG; RELEASE
  OBJCOPY.OOCOutputFile: i2c_twoBoards_comPolling_cpu1_eflash_release.bin
  ILINK.IlinkOutputFile: i2c_twoBoards_comPolling_cpu1_eflash_release.out
  ILINK.IlinkIcfFile: as above
  group board
    ../../../../../../../boards/evb_hs32f7d377/: board.c clock_config.c pin_config.c
  group component
    ../../../../../../../components/assert/: hte_assert.c
    ../../../../../../../components/debug_console/: hte_debug_console.c
  group device
    ../../../../../../../devices/HS32F7D377/: system_HS32F7D377_cpu1.c
  group driver
    ../../../../../../../drivers/common/: hte_common.c
    ../../../../../../../drivers/gpio/: hte_gpio.c
    ../../../../../../../drivers/i2c/: hte_i2c.c
    ../../../../../../../devices/HS32F7D377/drivers/: hte_sysctrl.c
    ../../../../../../../drivers/uart/: hte_uart.c
    ../../../../../../../drivers/xbar/: hte_xbar.c
  group source
    ../../: i2c_twoBoards_comPolling.c
  group startup
    ../../../../../../../devices/HS32F7D377/IAR/: startup_HS32F7D377_cpu1.s
