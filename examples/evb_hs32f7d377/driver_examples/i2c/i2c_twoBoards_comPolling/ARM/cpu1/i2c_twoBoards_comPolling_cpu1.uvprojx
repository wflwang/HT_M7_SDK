# Keil uVision project i2c_twoBoards_comPolling_cpu1.uvprojx, settings and files
target i2c_twoBoards_comPolling_cpu1_itcm_debug (6210000::V6.21::ARMCLANG)
  device: HS32F7D377:CPU1 Watech
  pack: Watech.HS32F7D377_DFP.1.0.0-alpa.3
  cpu: IRAM(0x00000000,0x20000) IRAM2(0x20000000,0x20000) IROM(0x00300000,0x100000) IROM2(0x10300000,0x100000) XRAM(0x00200000,0x20000) XRAM2(0x01000000,0x20000) XRAM3(0x21000000,0x20000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: i2c_twoBoards_comPolling_cpu1
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HTE_DEVICE_HS32F7D377_CPU1, BOARD_CONFIG_CPU2, DEBUG
  c misc: -fno-common -fdata-sections -ffreestanding -fno-builtin -mthumb
  c include: ..\..\..\..\..\..\..\CMSIS\Core\Include; ..\..\..\..\..\..\..\boards\evb_hs32f7d377; ..\..\..\..\..\..\..\components\debug_console; ..\..\..\..\..\..\..\devices\HS32F7D377; ..\..\..\..\..\..\..\devices\HS32F7D377\drivers; ..\..\..\..\..\..\..\drivers\common; ..\..\..\..\..\..\..\drivers\gpio; ..\..\..\..\..\..\..\drivers\i2c; ..\..\..\..\..\..\..\drivers\ipc; ..\..\..\..\..\..\..\drivers\uart; ..\..\..\..\..\..\..\drivers\xbar; ..\..\..\..\..\..\..\components
  asm define: HTE_DEVICE_HS32F7D377_CPU1, BOARD_CONFIG_CPU2, DEBUG
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x300000 size 0x100000
  memory RVCT5: ROM 0x10300000 size 0x100000
  memory RVCT6: RAM 0x200000 size 0x20000
  memory RVCT7: RAM 0x1000000 size 0x20000
  memory RVCT8: RAM 0x21000000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\..\..\..\devices\HS32F7D377\ARM\HS32F7D377_cpu1_ac6_itcm.sct
  group board
    ../../../../../../../boards/evb_hs32f7d377/: board.c clock_config.c pin_config.c
  group component
    ../../../../../../../components/assert/: hte_assert.c
    ../../../../../../../components/debug_console/: hte_debug_console.c
  group device
    ../../../../../../../devices/HS32F7D377/: system_HS32F7D377_cpu1.c
  group driver
    ../../../../../../../drivers/common/: hte_common.c
    ../../../../../../../drivers/gpio/: hte_gpio.c
    ../../../../../../../drivers/i2c/: hte_i2c.c
    ../../../../../../../devices/HS32F7D377/drivers/: hte_sysctrl.c
    ../../../../../../../drivers/uart/: hte_uart.c
    ../../../../../../../drivers/xbar/: hte_xbar.c
  group source
    ../../: i2c_twoBoards_comPolling.c
  group startup
    ../../../../../../../devices/HS32F7D377/ARM/: startup_HS32F7D377_cpu1_ac6.S
target i2c_twoBoards_comPolling_cpu1_itcm_release (6210000::V6.21::ARMCLANG)
  device: HS32F7D377:CPU1 Watech
  pack: Watech.HS32F7D377_DFP.1.0.0-alpa.3
  cpu: as above
  output: i2c_twoBoards_comPolling_cpu1
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HTE_DEVICE_HS32F7D377_CPU1, BOARD_CONFIG_CPU2, NDEBUG, RELEASE
  c misc: as above
  c include: as above
  asm define: HTE_DEVICE_HS32F7D377_CPU1, NDEBUG, RELEASE
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x300000 size 0x100000
  memory RVCT5: ROM 0x10300000 size 0x100000
  memory RVCT6: RAM 0x200000 size 0x20000
  memory RVCT7: RAM 0x1000000 size 0x20000
  memory RVCT8: RAM 0x21000000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: as above
target i2c_twoBoards_comPolling_cpu1_eflash_debug (6210000::V6.21::ARMCLANG)
  device: HS32F7D377:CPU1 Watech
  pack: Watech.HS32F7D377_DFP.1.0.0-alpa.3
  cpu: as above
  output: i2c_twoBoards_comPolling_cpu1
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HTE_DEVICE_HS32F7D377_CPU1, BOARD_CONFIG_CPU2, DEBUG
  c misc: as above
  c include: as above
  asm define: HTE_DEVICE_HS32F7D377_CPU1, BOARD_CONFIG_CPU2, DEBUG
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x300000 size 0x100000
  memory RVCT5: ROM 0x10300000 size 0x100000
  memory RVCT6: RAM 0x200000 size 0x20000
  memory RVCT7: RAM 0x1000000 size 0x20000
  memory RVCT8: RAM 0x21000000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\..\..\..\devices\HS32F7D377\ARM\HS32F7D377_cpu1_ac6_eflash.sct
target i2c_twoBoards_comPolling_cpu1_eflash_release (6210000::V6.21::ARMCLANG)
  device: HS32F7D377:CPU1 Watech
  pack: Watech.HS32F7D377_DFP.1.0.0-alpa.3
  cpu: as above
  output: i2c_twoBoards_comPolling_cpu1
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: as above
  c include: as above
  asm define: HTE_DEVICE_HS32F7D377_CPU1, NDEBUG, RELEASE
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x300000 size 0x100000
  memory RVCT5: ROM 0x10300000 size 0x100000
  memory RVCT6: RAM 0x200000 size 0x20000
  memory RVCT7: RAM 0x1000000 size 0x20000
  memory RVCT8: RAM 0x21000000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: as above
