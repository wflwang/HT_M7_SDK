<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\i2c_eeprom_cpu2.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>