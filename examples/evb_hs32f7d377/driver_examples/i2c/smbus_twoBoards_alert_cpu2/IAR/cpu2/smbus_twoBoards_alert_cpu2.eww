<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\smbus_twoBoards_alert_cpu2.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>