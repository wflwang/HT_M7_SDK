<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\tfu_ex1_sin_cpu2.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>