# IAR project tfu_ex1_sin_cpu1.ewp, settings and files
configuration tfu_ex1_sin_cpu1_itcm_debug (ARM, debug)
  General.OGChipSelectEditMenu: HS32F7D377_CPU1 Watech HS32F7D377_CPU1
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: HTE_DEVICE_HS32F7D377_CPU1; BOARD_CONFIG_CPU2; DEBUG
  ICCARM.CCIncludePath2: ..\..; ..\..\..\..\..\..\..\boards\evb_hs32f7d377; ..\..\..\..\..\..\..\components\debug_console; ..\..\..\..\..\..\..\devices\HS32F7D377; ..\..\..\..\..\..\..\devices\HS32F7D377\drivers; ..\..\..\..\..\..\..\drivers\common; ..\..\..\..\..\..\..\drivers\cputimer; ..\..\..\..\..\..\..\drivers\dma; ..\..\..\..\..\..\..\drivers\ecap; ..\..\..\..\..\..\..\drivers\epwm; ..\..\..\..\..\..\..\drivers\gpio; ..\..\..\..\..\..\..\drivers\ipc; ..\..\..\..\..\..\..\drivers\tfu; ..\..\..\..\..\..\..\drivers\uart; ..\..\..\..\..\..\..\drivers\xbar; ..\..\..\..\..\..\..\CMSIS\Core\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: HTE_DEVICE_HS32F7D377_CPU1; BOARD_CONFIG_CPU2; DEBUG
  OBJCOPY.OOCOutputFile: tfu_ex1_sin_cpu1_itcm_debug.srec
  ILINK.IlinkOutputFile: tfu_ex1_sin_cpu1_itcm_debug.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\devices\HS32F7D377\IAR\HS32F7D377_cpu1_itcm.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration tfu_ex1_sin_cpu1_itcm_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HTE_DEVICE_HS32F7D377_CPU1; BOARD_CONFIG_CPU2; NDEBUG; RELEASE
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\CMSIS\Core\Include; ..\..\..\..\..\..\..\boards\evb_hs32f7d377; ..\..\..\..\..\..\..\components\debug_console; ..\..\..\..\..\..\..\devices\HS32F7D377; ..\..\..\..\..\..\..\devices\HS32F7D377\drivers; ..\..\..\..\..\..\..\drivers\common; ..\..\..\..\..\..\..\drivers\cputimer; ..\..\..\..\..\..\..\drivers\dma; ..\..\..\..\..\..\..\drivers\ecap; ..\..\..\..\..\..\..\drivers\epwm; ..\..\..\..\..\..\..\drivers\gpio; ..\..\..\..\..\..\..\drivers\ipc; ..\..\..\..\..\..\..\drivers\tfu; ..\..\..\..\..\..\..\drivers\uart; ..\..\..\..\..\..\..\drivers\xbar; ..\..
  AARM.ADefines: HTE_DEVICE_HS32F7D377_CPU1; NDEBUG; RELEASE
  OBJCOPY.OOCOutputFile: tfu_ex1_sin_cpu1_itcm_release.bin
  ILINK.IlinkOutputFile: tfu_ex1_sin_cpu1_itcm_release.out
configuration tfu_ex1_sin_cpu1_eflash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\CMSIS\Core\Include; ..\..\..\..\..\..\..\boards\evb_hs32f7d377; ..\..\..\..\..\..\..\components\debug_console; ..\..\..\..\..\..\..\devices\HS32F7D377; ..\..\..\..\..\..\..\devices\HS32F7D377\drivers; ..\..\..\..\..\..\..\drivers\common; ..\..\..\..\..\..\..\drivers\cputimer; ..\..\..\..\..\..\..\drivers\dma; ..\..\..\..\..\..\..\drivers\epwm; ..\..\..\..\..\..\..\drivers\gpio; ..\..\..\..\..\..\..\drivers\ipc; ..\..\..\..\..\..\..\drivers\tfu; ..\..\..\..\..\..\..\drivers\uart; ..\..\..\..\..\..\..\drivers\xbar; ..\..
  AARM.ADefines: HTE_DEVICE_HS32F7D377_CPU1; DEBUG
  OBJCOPY.OOCOutputFile: tfu_ex1_sin_cpu1_eflash_debug.srec
  ILINK.IlinkOutputFile: tfu_ex1_sin_cpu1_eflash_debug.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\devices\HS32F7D377\IAR\HS32F7D377_cpu1_eflash.icf
configuration tfu_ex1_sin_cpu1_eflash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  AARM.ADefines: HTE_DEVICE_HS32F7D377_CPU1; NDEBUG; RELEASE
  OBJCOPY.OOCOutputFile: tfu_ex1_sin_cpu1_eflash_release.bin
  ILINK.IlinkOutputFile: tfu_ex1_sin_cpu1_eflash_release.out
  ILINK.IlinkIcfFile: as above
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/m-profile/: armv7m_cachel1.h armv7m_mpu.h cmsis_armclang_m.h
    ../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm7.h
  group board
    ../../../../../../../boards/evb_hs32f7d377/: board.c board.h clock_config.c clock_config.h pin_config.c pin_config.h
  group component
    ../../../../../../../components/assert/: hte_assert.c
    ../../../../../../../components/debug_console/: hte_debug_console.c hte_debug_console.h
  group device
    ../../../../../../../devices/HS32F7D377/: HS32F7D377_cpu1.h HS32F7D377_cpu1_features.h hte_device.h system_HS32F7D377_cpu1.c system_HS32F7D377_cpu1.h
  group driver
    ../../../../../../../drivers/common/: hte_common.c hte_common.h
    ../../../../../../../drivers/dma/: hte_dma.c
    ../../../../../../../drivers/ecap/: hte_ecap.c
    ../../../../../../../drivers/gpio/: hte_gpio.c hte_gpio.h
    ../../../../../../../devices/HS32F7D377/drivers/: hte_sysctrl.c hte_sysctrl.h
    ../../../../../../../drivers/tfu/: hte_tfu.c
    ../../../../../../../drivers/uart/: hte_uart.c hte_uart.h
    ../../../../../../../drivers/xbar/: hte_xbar.c
  group source
    ../../: tfu_ex1_sin.c
  group startup
    ../../../../../../../devices/HS32F7D377/IAR/: startup_HS32F7D377_cpu1.s
