<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\uart_interrupt_callback_cpu2.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>