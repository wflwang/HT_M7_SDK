<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\uart_rs485_fd_interrupt_callback_cpu1.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>