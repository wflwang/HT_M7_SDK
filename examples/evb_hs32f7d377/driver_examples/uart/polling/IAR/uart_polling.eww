<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\..\IAR\cpu1\uart_polling_cpu1.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\IAR\cpu2\uart_polling_cpu2.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>