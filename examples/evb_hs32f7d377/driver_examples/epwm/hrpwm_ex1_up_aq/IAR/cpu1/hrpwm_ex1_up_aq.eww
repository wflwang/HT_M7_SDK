<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\hrpwm_ex1_up_aq.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>