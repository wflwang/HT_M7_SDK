<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\epwm_ex1_up_aq_cpu1.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>