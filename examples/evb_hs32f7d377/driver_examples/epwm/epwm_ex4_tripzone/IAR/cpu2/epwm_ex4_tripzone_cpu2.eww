<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\epwm_ex4_tripzone_cpu2.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>