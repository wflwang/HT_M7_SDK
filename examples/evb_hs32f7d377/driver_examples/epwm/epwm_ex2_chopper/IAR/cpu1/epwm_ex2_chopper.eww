<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\epwm_ex2_chopper.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>