<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\ecap_apwm_cpu1.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>