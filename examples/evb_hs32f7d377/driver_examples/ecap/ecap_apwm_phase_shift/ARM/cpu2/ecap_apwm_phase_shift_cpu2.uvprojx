# Keil uVision project ecap_apwm_phase_shift_cpu2.uvprojx, settings and files
target ecap_apwm_cpu2_itcm_debug (6210000::V6.21::ARMCLANG)
  device: HS32F7D377:CPU2 Watech
  pack: Watech.HS32F7D377_DFP.1.0.0-alpa.3
  cpu: IRAM(0x00000000,0x20000) IRAM2(0x20000000,0x20000) IROM(0x10300000,0x100000) XRAM(0x00200000,0x20000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: ecap_apwm_phase_shift_cpu2
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HTE_DEVICE_HS32F7D377_CPU2, DEBUG
  c misc: -fno-common -fdata-sections -ffreestanding -fno-builtin -mthumb
  c include: ..\..\..\..\..\..\..\CMSIS\Core\Include; ..\..\..\..\..\..\..\boards\evb_hs32f7d377; ..\..\..\..\..\..\..\components\debug_console; ..\..\..\..\..\..\..\devices\HS32F7D377; ..\..\..\..\..\..\..\devices\HS32F7D377\drivers; ..\..\..\..\..\..\..\drivers\common; ..\..\..\..\..\..\..\drivers\cputimer; ..\..\..\..\..\..\..\drivers\dma; ..\..\..\..\..\..\..\drivers\ecap; ..\..\..\..\..\..\..\drivers\gpio; ..\..\..\..\..\..\..\drivers\ipc; ..\..\..\..\..\..\..\drivers\uart; ..\..\..\..\..\..\..\drivers\xbar; ..\..
  asm define: HTE_DEVICE_HS32F7D377_CPU2, DEBUG
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x300000 size 0x100000
  memory RVCT5: ROM 0x10300000 size 0x100000
  memory RVCT6: RAM 0x200000 size 0x20000
  memory RVCT7: RAM 0x1000000 size 0x20000
  memory RVCT8: RAM 0x21000000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\..\..\..\devices\HS32F7D377\ARM\HS32F7D377_cpu2_ac6_itcm.sct
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/m-profile/: armv7m_cachel1.h armv7m_mpu.h cmsis_armclang_m.h
    ../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm7.h
  group board
    ../../../../../../../boards/evb_hs32f7d377/: board.c board.h clock_config.c clock_config.h
  group component
    ../../../../../../../components/assert/: hte_assert.c
    ../../../../../../../components/debug_console/: hte_debug_console.c hte_debug_console.h
  group device
    ../../../../../../../devices/HS32F7D377/: HS32F7D377_cpu2.h HS32F7D377_cpu2_features.h hte_device.h system_HS32F7D377_cpu2.c system_HS32F7D377_cpu2.h
  group driver
    ../../../../../../../drivers/common/: hte_common.c hte_common.h
    ../../../../../../../drivers/ecap/: hte_ecap.c
    ../../../../../../../drivers/gpio/: hte_gpio.c hte_gpio.h
    ../../../../../../../drivers/uart/: hte_uart.c hte_uart.h
    ../../../../../../../drivers/xbar/: hte_xbar.c
  group source
    ../../: ecap_apwm_phase_shift.c
  group startup
    ../../../../../../../devices/HS32F7D377/ARM/: startup_HS32F7D377_cpu2_ac6.S
target ecap_apwm_cpu2_itcm_release (6210000::V6.21::ARMCLANG)
  device: HS32F7D377:CPU2 Watech
  pack: Watech.HS32F7D377_DFP.1.0.0-alpa.3
  cpu: as above
  output: ecap_apwm_phase_shift_cpu2
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HTE_DEVICE_HS32F7D377_CPU2, NDEBUG, RELEASE
  c misc: as above
  c include: ..\..\..\..\..\..\..\CMSIS\Core\Include; ..\..\..\..\..\..\..\boards\evb_hs32f7d377; ..\..\..\..\..\..\..\boards\evb_hs32f7d377; ..\..\..\..\..\..\..\components\debug_console; ..\..\..\..\..\..\..\devices\HS32F7D377; ..\..\..\..\..\..\..\devices\HS32F7D377\drivers; ..\..\..\..\..\..\..\drivers\common; ..\..\..\..\..\..\..\drivers\ecap; ..\..\..\..\..\..\..\drivers\gpio; ..\..\..\..\..\..\..\drivers\uart; ..\..
  asm define: HTE_DEVICE_HS32F7D377_CPU2, NDEBUG, RELEASE
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x300000 size 0x100000
  memory RVCT5: ROM 0x10300000 size 0x100000
  memory RVCT6: RAM 0x200000 size 0x20000
  memory RVCT7: RAM 0x1000000 size 0x20000
  memory RVCT8: RAM 0x21000000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: as above
target ecap_apwm_cpu2_eflash_debug (6210000::V6.21::ARMCLANG)
  device: HS32F7D377:CPU2 Watech
  pack: Watech.HS32F7D377_DFP.1.0.0-alpa.3
  cpu: as above
  output: ecap_apwm_phase_shift_cpu2
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HTE_DEVICE_HS32F7D377_CPU2, DEBUG
  c misc: as above
  c include: ..\..\..\..\..\..\..\CMSIS\Core\Include; ..\..\..\..\..\..\..\boards\evb_hs32f7d377; ..\..\..\..\..\..\..\components\debug_console; ..\..\..\..\..\..\..\devices\HS32F7D377; ..\..\..\..\..\..\..\devices\HS32F7D377\drivers; ..\..\..\..\..\..\..\drivers\common; ..\..\..\..\..\..\..\drivers\ecap; ..\..\..\..\..\..\..\drivers\gpio; ..\..\..\..\..\..\..\drivers\ipc; ..\..\..\..\..\..\..\drivers\uart; ..\..
  asm define: HTE_DEVICE_HS32F7D377_CPU2, DEBUG
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x300000 size 0x100000
  memory RVCT5: ROM 0x10300000 size 0x100000
  memory RVCT6: RAM 0x200000 size 0x20000
  memory RVCT7: RAM 0x1000000 size 0x20000
  memory RVCT8: RAM 0x21000000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\..\..\..\devices\HS32F7D377\ARM\HS32F7D377_cpu2_ac6_eflash.sct
target ecap_apwm_cpu2_eflash_release (6210000::V6.21::ARMCLANG)
  device: HS32F7D377:CPU2 Watech
  pack: Watech.HS32F7D377_DFP.1.0.0-alpa.3
  cpu: as above
  output: ecap_apwm_phase_shift_cpu2
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HTE_DEVICE_HS32F7D377_CPU2, NDEBUG, RELEASE
  c misc: as above
  c include: ..\..\..\..\..\..\..\CMSIS\Core\Include; ..\..\..\..\..\..\..\boards\evb_hs32f7d377; ..\..\..\..\..\..\..\components\debug_console; ..\..\..\..\..\..\..\devices\HS32F7D377; ..\..\..\..\..\..\..\devices\HS32F7D377\drivers; ..\..\..\..\..\..\..\drivers\common; ..\..\..\..\..\..\..\drivers\ecap; ..\..\..\..\..\..\..\drivers\gpio; ..\..\..\..\..\..\..\drivers\uart; ..\..
  asm define: HTE_DEVICE_HS32F7D377_CPU2, NDEBUG, RELEASE
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x300000 size 0x100000
  memory RVCT5: ROM 0x10300000 size 0x100000
  memory RVCT6: RAM 0x200000 size 0x20000
  memory RVCT7: RAM 0x1000000 size 0x20000
  memory RVCT8: RAM 0x21000000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: as above
