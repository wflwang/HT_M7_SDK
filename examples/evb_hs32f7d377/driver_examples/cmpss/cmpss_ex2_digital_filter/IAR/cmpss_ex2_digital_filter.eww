<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\..\IAR\cpu1\cmpss_ex2_digital_filter_cpu1.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\IAR\cpu2\cmpss_ex2_digital_filter_cpu2.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>