<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\cpu1\crc_ex1_calculate_cpu1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\cpu2\crc_ex1_calculate_cpu2.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>build all</name>
            <member>
                <project>crc_ex1_calculate_cpu1</project>
                <configuration>crc_ex1_calculate_cpu1_eflash_debug</configuration>
            </member>
            <member>
                <project>crc_ex1_calculate_cpu1</project>
                <configuration>crc_ex1_calculate_cpu1_eflash_release</configuration>
            </member>
            <member>
                <project>crc_ex1_calculate_cpu1</project>
                <configuration>crc_ex1_calculate_cpu1_itcm_debug</configuration>
            </member>
            <member>
                <project>crc_ex1_calculate_cpu1</project>
                <configuration>crc_ex1_calculate_cpu1_itcm_release</configuration>
            </member>
            <member>
                <project>crc_ex1_calculate_cpu2</project>
                <configuration>crc_ex1_calculate_cpu2_eflash_debug</configuration>
            </member>
            <member>
                <project>crc_ex1_calculate_cpu2</project>
                <configuration>crc_ex1_calculate_cpu2_eflash_release</configuration>
            </member>
            <member>
                <project>crc_ex1_calculate_cpu2</project>
                <configuration>crc_ex1_calculate_cpu2_itcm_debug</configuration>
            </member>
            <member>
                <project>crc_ex1_calculate_cpu2</project>
                <configuration>crc_ex1_calculate_cpu2_itcm_release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
