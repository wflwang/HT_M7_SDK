<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\crc_ex1_calculate_cpu2.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>