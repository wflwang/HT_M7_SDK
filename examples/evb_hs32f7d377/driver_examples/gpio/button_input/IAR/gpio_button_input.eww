<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\..\IAR\cpu1\gpio_button_input_cpu1.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\IAR\cpu2\gpio_button_input_cpu2.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>