<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\gpio_button_input_cpu1.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>