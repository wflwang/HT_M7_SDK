<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\mcan_ex7_external_trx_cpu2.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>