<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\cpu1\mcan_ex7_external_trx_cpu1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\cpu2\mcan_ex7_external_trx_cpu2.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>1</name>
            <member>
                <project>mcan_ex7_external_trx_cpu1</project>
                <configuration>mcan_ex7_external_trx_cpu1_eflash_debug</configuration>
            </member>
            <member>
                <project>mcan_ex7_external_trx_cpu1</project>
                <configuration>mcan_ex7_external_trx_cpu1_eflash_release</configuration>
            </member>
            <member>
                <project>mcan_ex7_external_trx_cpu1</project>
                <configuration>mcan_ex7_external_trx_cpu1_itcm_debug</configuration>
            </member>
            <member>
                <project>mcan_ex7_external_trx_cpu1</project>
                <configuration>mcan_ex7_external_trx_cpu1_itcm_release</configuration>
            </member>
            <member>
                <project>mcan_ex7_external_trx_cpu2</project>
                <configuration>mcan_ex7_external_trx_cpu2_eflash_debug</configuration>
            </member>
            <member>
                <project>mcan_ex7_external_trx_cpu2</project>
                <configuration>mcan_ex7_external_trx_cpu2_eflash_release</configuration>
            </member>
            <member>
                <project>mcan_ex7_external_trx_cpu2</project>
                <configuration>mcan_ex7_external_trx_cpu2_itcm_debug</configuration>
            </member>
            <member>
                <project>mcan_ex7_external_trx_cpu2</project>
                <configuration>mcan_ex7_external_trx_cpu2_itcm_release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
