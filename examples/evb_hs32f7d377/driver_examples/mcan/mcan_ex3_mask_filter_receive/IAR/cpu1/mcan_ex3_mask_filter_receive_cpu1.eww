<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\mcan_ex3_mask_filter_receive_cpu1.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>