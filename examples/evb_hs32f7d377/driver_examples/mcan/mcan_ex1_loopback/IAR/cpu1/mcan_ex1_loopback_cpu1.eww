<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\mcan_ex1_loopback_cpu1.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>