<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\dma_dtcm_cpu1.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>