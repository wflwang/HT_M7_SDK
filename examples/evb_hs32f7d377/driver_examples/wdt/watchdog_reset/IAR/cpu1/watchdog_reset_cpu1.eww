<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\watchdog_reset_cpu1.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>