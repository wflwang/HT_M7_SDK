<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\eqep_ex4_freq_cal_interrupt_cpu2.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>