<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\eqep_ex5_speed_dir_motor_cpu1.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>