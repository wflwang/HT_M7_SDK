<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\eqep_ex3_epwm_xbar_cpu2.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>