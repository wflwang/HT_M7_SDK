<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\eqep_ex2_pos_speed_cpu1.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>