<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\dac_ex2_multicore_cpu1.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>