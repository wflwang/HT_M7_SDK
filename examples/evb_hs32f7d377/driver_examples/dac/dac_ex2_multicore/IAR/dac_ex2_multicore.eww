<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\..\IAR\cpu1\dac_ex2_multicore_cpu1.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\IAR\cpu2\dac_ex2_multicore_cpu2.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>