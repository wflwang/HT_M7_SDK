<?xml version="1.0" encoding="utf-8"?>
<workspace>
	<project>
		<path>$WS_DIR$\rfft_adc_f32_cpu1.ewp</path>
	</project>
	<batchBuild></batchBuild>
</workspace>