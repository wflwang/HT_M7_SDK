# IAR project rfft_adc_f32_cpu2.ewp, settings and files
configuration rfft_adc_f32_cpu2_itcm_debug (ARM, debug)
  General.OGChipSelectEditMenu: HS32F7D377_CPU2 Watech HS32F7D377_CPU2
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: HTE_DEVICE_HS32F7D377_CPU2; DEBUG
  ICCARM.CCIncludePath2: ..\..; ..\..\..\..\..\..\CMSIS\Core\Include; ..\..\..\..\..\..\CMSIS\DSP\Include; ..\..\..\..\..\..\boards\evb_hs32f7d377; ..\..\..\..\..\..\components\debug_console; ..\..\..\..\..\..\devices\HS32F7D377; ..\..\..\..\..\..\devices\HS32F7D377\drivers; ..\..\..\..\..\..\drivers\adc; ..\..\..\..\..\..\drivers\common; ..\..\..\..\..\..\drivers\eflash; ..\..\..\..\..\..\drivers\epwm; ..\..\..\..\..\..\drivers\gpio; ..\..\..\..\..\..\drivers\uart
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: HTE_DEVICE_HS32F7D377_CPU2; DEBUG
  OBJCOPY.OOCOutputFile: rfft_adc_f32_cpu2_itcm_debug.srec
  ILINK.IlinkOutputFile: rfft_adc_f32_cpu2_itcm_debug.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\devices\HS32F7D377\IAR\HS32F7D377_cpu2_itcm.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration rfft_adc_f32_cpu2_itcm_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HTE_DEVICE_HS32F7D377_CPU2; NDEBUG; RELEASE
  AARM.ADefines: HTE_DEVICE_HS32F7D377_CPU2; NDEBUG; RELEASE
  OBJCOPY.OOCOutputFile: rfft_adc_f32_cpu2_itcm_release.srec
  ILINK.IlinkOutputFile: rfft_adc_f32_cpu2_itcm_release.out
configuration rfft_adc_f32_cpu2_eflash_debug (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: rfft_adc_f32_cpu2_eflash_debug.srec
  ILINK.IlinkOutputFile: rfft_adc_f32_cpu2_eflash_debug.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\devices\HS32F7D377\IAR\HS32F7D377_cpu2_eflash.icf
configuration rfft_adc_f32_cpu2_eflash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HTE_DEVICE_HS32F7D377_CPU2; NDEBUG; RELEASE
  AARM.ADefines: HTE_DEVICE_HS32F7D377_CPU2; NDEBUG; RELEASE
  OBJCOPY.OOCOutputFile: rfft_adc_f32_cpu2_eflash_release.srec
  ILINK.IlinkOutputFile: rfft_adc_f32_cpu2_eflash_release.out
  ILINK.IlinkIcfFile: as above
  group CMSIS
    ../../../../../../CMSIS/DSP/Source/TransformFunctions/: arm_bitreversal2.c arm_cfft_f32.c arm_cfft_init_f32.c arm_cfft_radix8_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c
    ../../../../../../CMSIS/DSP/Source/ComplexMathFunctions/: arm_cmplx_mag_f32.c
    ../../../../../../CMSIS/DSP/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
    ../../../../../../CMSIS/DSP/Include/: arm_math.h
    ../../../../../../CMSIS/DSP/Source/StatisticsFunctions/: arm_max_f32.c
    ../../../../../../CMSIS/Core/Include/m-profile/: armv7m_cachel1.h armv7m_mpu.h cmsis_armclang_m.h
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm7.h
  group board
    ../../../../../../boards/evb_hs32f7d377/: board.c board.h clock_config.c clock_config.h
  group component
    ../../../../../../components/assert/: hte_assert.c
    ../../../../../../components/debug_console/: hte_debug_console.c hte_debug_console.h
  group device
    ../../../../../../devices/HS32F7D377/: HS32F7D377_cpu2.h HS32F7D377_cpu2_arrays.h HS32F7D377_cpu2_features.h hte_device.h system_HS32F7D377_cpu2.c system_HS32F7D377_cpu2.h
  group driver
    ../../../../../../drivers/adc/: hte_adc.c hte_adc.h
    ../../../../../../devices/HS32F7D377/drivers/: hte_calib.c hte_calib.h
    ../../../../../../drivers/common/: hte_common.c hte_common.h
    ../../../../../../drivers/eflash/: hte_eflash.c hte_eflash.h
    ../../../../../../drivers/epwm/: hte_epwm.c hte_epwm.h
    ../../../../../../drivers/gpio/: hte_gpio.c hte_gpio.h
    ../../../../../../drivers/uart/: hte_uart.c hte_uart.h
  group source
    ../../: rfft_adc_f32.c
  group startup
    ../../../../../../devices/HS32F7D377/IAR/: startup_HS32F7D377_cpu2.s
