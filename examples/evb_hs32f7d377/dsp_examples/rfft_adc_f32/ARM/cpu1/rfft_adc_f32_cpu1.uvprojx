# Keil uVision project rfft_adc_f32_cpu1.uvprojx, settings and files
target rfft_adc_f32_cpu1_itcm_debug (6210000::V6.21::ARMCLANG)
  device: HS32F7D377:CPU1 Watech
  pack: Watech.HS32F7D377_DFP.1.0.0-alpa.3
  cpu: IRAM(0x00000000,0x20000) IRAM2(0x20000000,0x20000) IROM(0x00300000,0x100000) IROM2(0x10300000,0x100000) XRAM(0x00200000,0x20000) XRAM2(0x01000000,0x20000) XRAM3(0x21000000,0x20000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: rfft_adc_f32_cpu1
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HTE_DEVICE_HS32F7D377_CPU1, BOARD_CONFIG_CPU2, DEBUG
  c misc: -fno-common -fdata-sections -ffreestanding -fno-builtin -mthumb
  c include: ..\..; ..\..\..\..\..\..\CMSIS\Core\Include; ..\..\..\..\..\..\CMSIS\DSP\Include; ..\..\..\..\..\..\boards\evb_hs32f7d377; ..\..\..\..\..\..\components\debug_console; ..\..\..\..\..\..\devices\HS32F7D377; ..\..\..\..\..\..\devices\HS32F7D377\drivers; ..\..\..\..\..\..\drivers\adc; ..\..\..\..\..\..\drivers\common; ..\..\..\..\..\..\drivers\eflash; ..\..\..\..\..\..\drivers\epwm; ..\..\..\..\..\..\drivers\gpio; ..\..\..\..\..\..\drivers\ipc; ..\..\..\..\..\..\drivers\uart; ..\..\..\..\..\..\drivers\xbar
  asm define: HTE_DEVICE_HS32F7D377_CPU1, DEBUG
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x300000 size 0x100000
  memory RVCT5: ROM 0x10300000 size 0x100000
  memory RVCT6: RAM 0x200000 size 0x20000
  memory RVCT7: RAM 0x1000000 size 0x20000
  memory RVCT8: RAM 0x21000000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\..\..\devices\HS32F7D377\ARM\HS32F7D377_cpu1_ac6_itcm.sct
  group CMSIS
    ../../../../../../CMSIS/DSP/Source/TransformFunctions/: arm_bitreversal2.c arm_cfft_f32.c arm_cfft_init_f32.c arm_cfft_radix8_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c
    ../../../../../../CMSIS/DSP/Source/ComplexMathFunctions/: arm_cmplx_mag_f32.c
    ../../../../../../CMSIS/DSP/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
    ../../../../../../CMSIS/DSP/Include/: arm_math.h
    ../../../../../../CMSIS/DSP/Source/StatisticsFunctions/: arm_max_f32.c
    ../../../../../../CMSIS/Core/Include/m-profile/: armv7m_cachel1.h armv7m_mpu.h cmsis_armclang_m.h
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm7.h
  group board
    ../../../../../../boards/evb_hs32f7d377/: board.c board.h clock_config.c clock_config.h pin_config.c pin_config.h
  group component
    ../../../../../../components/assert/: hte_assert.c
    ../../../../../../components/debug_console/: hte_debug_console.c hte_debug_console.h
  group device
    ../../../../../../devices/HS32F7D377/: HS32F7D377_cpu1.h HS32F7D377_cpu1_arrays.h HS32F7D377_cpu1_features.h hte_device.h system_HS32F7D377_cpu1.c system_HS32F7D377_cpu1.h
  group driver
    ../../../../../../drivers/adc/: hte_adc.c hte_adc.h
    ../../../../../../devices/HS32F7D377/drivers/: hte_calib.c hte_calib.h hte_pinmux.h hte_sysctrl.c hte_sysctrl.h hte_xbarmux.h
    ../../../../../../drivers/common/: hte_common.c hte_common.h
    ../../../../../../drivers/eflash/: hte_eflash.c hte_eflash.h
    ../../../../../../drivers/epwm/: hte_epwm.c hte_epwm.h
    ../../../../../../drivers/gpio/: hte_gpio.c hte_gpio.h
    ../../../../../../drivers/uart/: hte_uart.c hte_uart.h
    ../../../../../../drivers/xbar/: hte_xbar.c hte_xbar.h
  group source
    ../../: rfft_adc_f32.c
  group startup
    ../../../../../../devices/HS32F7D377/ARM/: startup_HS32F7D377_cpu1_ac6.S
target rfft_adc_f32_cpu1_itcm_release (6210000::V6.21::ARMCLANG)
  device: HS32F7D377:CPU1 Watech
  pack: Watech.HS32F7D377_DFP.1.0.0-alpa.3
  cpu: as above
  output: rfft_adc_f32_cpu1
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HTE_DEVICE_HS32F7D377_CPU1, BOARD_CONFIG_CPU2, NDEBUG, RELEASE
  c misc: as above
  c include: as above
  asm define: HTE_DEVICE_HS32F7D377_CPU1, NDEBUG, RELEASE
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x300000 size 0x100000
  memory RVCT5: ROM 0x10300000 size 0x100000
  memory RVCT6: RAM 0x200000 size 0x20000
  memory RVCT7: RAM 0x1000000 size 0x20000
  memory RVCT8: RAM 0x21000000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: as above
target rfft_adc_f32_cpu1_eflash_debug (6210000::V6.21::ARMCLANG)
  device: HS32F7D377:CPU1 Watech
  pack: Watech.HS32F7D377_DFP.1.0.0-alpa.3
  cpu: as above
  output: rfft_adc_f32_cpu1
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HTE_DEVICE_HS32F7D377_CPU1, BOARD_CONFIG_CPU2, DEBUG
  c misc: as above
  c include: as above
  asm define: HTE_DEVICE_HS32F7D377_CPU1, DEBUG
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x300000 size 0x100000
  memory RVCT5: ROM 0x10300000 size 0x100000
  memory RVCT6: RAM 0x200000 size 0x20000
  memory RVCT7: RAM 0x1000000 size 0x20000
  memory RVCT8: RAM 0x21000000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\..\..\devices\HS32F7D377\ARM\HS32F7D377_cpu1_ac6_eflash.sct
target rfft_adc_f32_cpu1_eflash_release (6210000::V6.21::ARMCLANG)
  device: HS32F7D377:CPU1 Watech
  pack: Watech.HS32F7D377_DFP.1.0.0-alpa.3
  cpu: as above
  output: rfft_adc_f32_cpu1
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: as above
  c include: as above
  asm define: HTE_DEVICE_HS32F7D377_CPU1, NDEBUG, RELEASE
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x300000 size 0x100000
  memory RVCT5: ROM 0x10300000 size 0x100000
  memory RVCT6: RAM 0x200000 size 0x20000
  memory RVCT7: RAM 0x1000000 size 0x20000
  memory RVCT8: RAM 0x21000000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: as above
