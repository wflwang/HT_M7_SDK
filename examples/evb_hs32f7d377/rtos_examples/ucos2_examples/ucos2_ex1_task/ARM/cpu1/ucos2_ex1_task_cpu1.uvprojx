# Keil uVision project ucos2_ex1_task_cpu1.uvprojx, settings and files
target ucos2_ex1_task_cpu1_itcm_release (6210000::V6.21::ARMCLANG)
  device: ARMCM7_SP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ESEL ELITTLE
  output: demo1_cpu1
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HTE_DEVICE_HS32F7D377_CPU1, BOARD_CONFIG_CPU2, NDEBUG, RELEASE
  c misc: -fno-common -fdata-sections -ffreestanding -fno-builtin -mthumb
  c include: ..\..;..\..\..\..\..\..\..\rtos\uC-OS2\Source;..\..\..\..\..\..\..\rtos\uC-OS2\Ports\ARM-Cortex-M\ARMv7-M\ARM;..\..\..\..\..\..\..\CMSIS\Core\Include;..\..\..\..\..\..\..\drivers\common;..\..\..\..\..\..\..\drivers\epwm;..\..\..\..\..\..\..\devices\HS32F7D377;..\..\..\..\..\..\..\components\debug_console;..\..\..\..\..\..\..\drivers\xbar;..\..\..\..\..\..\..\drivers\gpio;..\..\..\..\..\..\..\drivers\uart;..\..\..\..\..\..\..\boards\evb_hs32f7d377;..\..\..\..\..\..\..\devices\HS32F7D377\drivers;..\..\..\..\..\..\..\drivers\ipc
  asm define: HTE_DEVICE_HS32F7D377_CPU1, NDEBUG, RELEASE
  asm misc: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\..\..\..\devices\HS32F7D377\ARM\HS32F7D377_cpu1_ac6_itcm.sct
  group board
    ../../../../../../../boards/evb_hs32f7d377/: board.c board.h clock_config.c clock_config.h pin_config.c pin_config.h
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/m-profile/: armv7m_cachel1.h cmsis_armclang_m.h armv7m_mpu.h
    ../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm7.h
  group source
    ../../: ucos2_ex1_task.c
  group driver
    ../../../../../../../drivers/common/: hte_common.c
    ../../../../../../../drivers/gpio/: hte_gpio.c
    ../../../../../../../drivers/xbar/: hte_xbar.c
    ../../../../../../../drivers/uart/: hte_uart.c
    ../../../../../../../devices/HS32F7D377/drivers/: hte_sysctrl.c
  group device
    ../../../../../../../devices/HS32F7D377/: hte_device.h system_HS32F7D377_cpu1.c system_HS32F7D377_cpu1.h HS32F7D377_cpu1.h HS32F7D377_cpu1_features.h
  group startup
    ../../../../../../../devices/HS32F7D377/ARM/: startup_HS32F7D377_cpu1_ac6.S
  group component
    ../../../../../../../components/debug_console/: hte_debug_console.c
    ../../../../../../../components/assert/: hte_assert.c
  group ucosii
    ../../: os_cfg.h app_cfg.h
    ../../../../../../../rtos/uC-OS2/Source/: os_core.c os_flag.c os_mem.c os_mutex.c os_sem.c os_task.c os_time.c os_tmr.c os_q.c os_mbox.c
    ../../../../../../../rtos/uC-OS2/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../../../../../../../rtos/uC-OS2/Ports/ARM-Cortex-M/ARMv7-M/GNU/: os_cpu_a.S
target ucos2_ex1_task_cpu1_eflash_release (6210000::V6.21::ARMCLANG)
  device: ARMCM7_SP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: demo1_cpu1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: as above
  c include: as above
  asm define: HTE_DEVICE_HS32F7D377_CPU1, NDEBUG, RELEASE
  asm misc: as above
  memory RVCT1: ROM 0x60200000 size 0x10000
  memory RVCT4: ROM 0x60100000 size 0x10000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\..\..\..\devices\HS32F7D377\ARM\HS32F7D377_cpu1_ac6_eflash.sct
