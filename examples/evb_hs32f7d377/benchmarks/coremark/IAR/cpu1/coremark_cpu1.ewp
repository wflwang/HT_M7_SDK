# IAR project coremark_cpu1.ewp, settings and files
configuration coremark_cpu1_itcm_release (ARM)
  General.OGChipSelectEditMenu: HS32F7D377_CPU1 Watech HS32F7D377_CPU1
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_ADD_EXTRA_SYMBOLS=0; HTE_DEVICE_HS32F7D377_CPU1; BOARD_CONFIG_CPU2; NDEBUG; RELEASE
  ICCARM.IExtraOptions: --use_c++_inline; --no_size_constraints
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\CMSIS\Core\Include; ..\..\..\..\..\..\boards\evb_hs32f7d377; ..\..\..\..\..\..\components\debug_console; ..\..\..\..\..\..\devices\HS32F7D377; ..\..\..\..\..\..\devices\HS32F7D377\drivers; ..\..\..\..\..\..\drivers\common; ..\..\..\..\..\..\drivers\cputimer; ..\..\..\..\..\..\drivers\gpio; ..\..\..\..\..\..\drivers\ipc; ..\..\..\..\..\..\drivers\uart; ..\..\..\..\..\..\drivers\xbar; ..\..\barebones; ..\..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: HTE_DEVICE_HS32F7D377_CPU1; NDEBUG; RELEASE
  OBJCOPY.OOCOutputFile: coremark_cpu1_itcm_release.srec
  ILINK.IlinkOutputFile: coremark_cpu1_itcm_release.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\devices\HS32F7D377\IAR\HS32F7D377_cpu1_itcm.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration coremark_cpu1_eflash_release (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: coremark_cpu1_eflash_release.srec
  ILINK.IlinkOutputFile: coremark_cpu1_eflash_release.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\devices\HS32F7D377\IAR\HS32F7D377_cpu1_eflash.icf
  group CMSIS
    ../../../../../../CMSIS/Core/Include/m-profile/: armv7m_cachel1.h armv7m_mpu.h cmsis_armclang_m.h
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm7.h
  group board
    ../../../../../../boards/evb_hs32f7d377/: board.c board.h clock_config.c clock_config.h pin_config.c pin_config.h
  group component
    ../../../../../../components/assert/: hte_assert.c
    ../../../../../../components/debug_console/: hte_debug_console.c hte_debug_console.h
  group device
    ../../../../../../devices/HS32F7D377/: HS32F7D377_cpu1.h HS32F7D377_cpu1_arrays.h HS32F7D377_cpu1_features.h hte_device.h system_HS32F7D377_cpu1.c system_HS32F7D377_cpu1.h
  group driver
    ../../../../../../drivers/common/: hte_common.c hte_common.h
    ../../../../../../drivers/cputimer/: hte_cputimer.c hte_cputimer.h
    ../../../../../../drivers/gpio/: hte_gpio.c hte_gpio.h
    ../../../../../../devices/HS32F7D377/drivers/: hte_pinmux.h hte_sysctrl.c hte_sysctrl.h
    ../../../../../../drivers/uart/: hte_uart.c hte_uart.h
    ../../../../../../drivers/xbar/: hte_xbar.c hte_xbar.h
  group source
    ../../: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c coremark.h
    ../../barebones/: core_portme.c core_portme.h cvt.c ee_printf.c
  group startup
    ../../../../../../devices/HS32F7D377/IAR/: startup_HS32F7D377_cpu1.s
